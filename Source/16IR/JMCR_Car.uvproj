# Keil uVision project JMCR_Car.uvproj, settings and files
target STC15W4K32S4 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: JMCR_Car +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HARDWARE;.\LIB
  group LIB
    ./LIB/: IO.c PWM.c USART.c STDFUNC.c IO.h PWM.h STC15.h STDFUNC.h USART.h
  group HARDWARE
    ./HARDWARE/: SERVO.c MOTOR.c PID.c SENSOR.c MOTOR.h PID.h SERVO.h SENSOR.h
  group USER
    ./USER/: JMCR_Car.c
